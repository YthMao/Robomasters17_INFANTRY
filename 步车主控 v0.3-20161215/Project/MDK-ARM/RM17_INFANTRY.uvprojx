# Keil uVision project RM17_INFANTRY.uvprojx, settings and files
target Test (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: RM17_INFANTRY +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F4XX,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\User;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\BaseDrive;..\..\HARDWARE\BUZZER;..\..\HARDWARE\CAN;..\..\HARDWARE\COM2MANI;..\..\HARDWARE\CAN2;..\..\HARDWARE\KEY;..\..\HARDWARE\LCD;..\..\HARDWARE\LED;..\..\HARDWARE\MPU6050;..\..\HARDWARE\PWM;..\..\HARDWARE\RC;..\..\HARDWARE\TIMR;..\..\HARDWARE\UART3;..\..\HARDWARE\VIEW;..\..\HARDWARE\sys;..\..\HARDWARE\delay;..\..\HARDWARE\UART1;..\..\HARDWARE\LASER;..\..\APP\Controltask;..\..\APP\COM2MANI;..\..\APP\MOTOR;..\..\APP\MOTORCONTROL;..\..\APP\MOVE;..\..\APP\PID;..\..\HARDWARE\BSP;..\..\HARDWARE\GUN;..\..\APP\CMCONTROL;..\..\APP\GIMBALCONTROL;..\..\APP\IMUCONTROL;..\..\APP\REMOTECONTROL;..\..\APP\SHOOTCONTROL;..\..\TASK\Controltask;..\..\HARDWARE\GIMBALMOTOR
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Cmsis
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group User
    ../../User/: main.c stm32f4xx_it.c
  group BSP
    ../../HARDWARE/BSP/: bsp.c
    ../../HARDWARE/sys/: sys.c
    ../../HARDWARE/delay/: delay.c
    ../../HARDWARE/UART1/: usart1.c
    ../../HARDWARE/UART3/: usart3.c
    ../../HARDWARE/TIMR/: timer.c
    ../../HARDWARE/BUZZER/: buzzer.c
    ../../HARDWARE/LED/: led.c
    ../../HARDWARE/LASER/: laser.c
    ../../HARDWARE/GUN/: gun.c
    ../../HARDWARE/CAN/: can.c
    ../../HARDWARE/CAN2/: can2.c
    ../../HARDWARE/KEY/: key.c
    ../../HARDWARE/RC/: rc.c
    ../../HARDWARE/GIMBALMOTOR/: GimbalMotor.c
    ../../HARDWARE/MPU6050/: mpu6050_i2c.c mpu6050_driver.c mpu6050_process.c
  group APP
    ../../APP/CMCONTROL/: CMControl.c
    ../../APP/GIMBALCONTROL/: GimbalControl.c
    ../../APP/PID/: pid.c
    ../../APP/IMUCONTROL/: IMUControl.c
    ../../APP/REMOTECONTROL/: RemoteControl.c
    ../../APP/SHOOTCONTROL/: ShootControl.c
  group Lib
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group TASK
    ../../TASK/Controltask/: ControlTask.c
software components: CMSIS:CORE 3.30.0
